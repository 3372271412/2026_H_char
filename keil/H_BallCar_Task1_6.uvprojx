# Keil uVision project H_BallCar_Task1_6.uvprojx, settings and files
target H_BallCar_Task1_6 (6240000::V6.24::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: H_BallCar_Task1_6 +hex
  BeforeMake: cmd.exe /C call "$Psyscfg.bat" "$P" main.syscfg
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ../;../Component;C:\ti\mspm0_sdk_2_10_00_04\source\third_party\CMSIS\Core\Include;C:\ti\mspm0_sdk_2_10_00_04\source;.\FreeRTOS\include;.\FreeRTOS\portable\GCC\ARM_CM0;.\FreeRTOS\portable\MemMang;C:\ti\mspm0_sdk_2_10_00_04\source;C:\ti\mspm0_sdk_2_10_00_04\source\third_party\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: C:\ti\mspm0_sdk_2_10_00_04\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Source
    ../: main.c main.syscfg FreeRTOSConfig.h ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g350x_uvision.s
  group FreeRTOS/src
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ./FreeRTOS/portable/GCC/ARM_CM0/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group Component/led
    ../Component/led/: led.c led.h key.c key.h
  group Component/oled
    ../Component/oled/: oled.c oled.h oledfont.h bmp.h
  group Component/tb6612
    ../Component/tb6612/: tb6612.c tb6612.h
  group Component/encoder
    ../Component/encoder/: encoder.c encoder.h
  group Component/stepper
    ../Component/stepper/: Emm_V5.c Emm_V5.h
  group Component/pid
    ../Component/pid/: pid.c pid.h
  group Component/control
    ../Component/control/: speed_loop_core.c speed_loop_core.h distance_control.c distance_control.h control2.c control2.h line_tracking_control.c line_tracking_control.h line_tracking_config.h
  group Component/service
    ../Component/service/: speed_service.c speed_service.h line_tracking_service.c line_tracking_service.h
  group Component/common
    ../Component/common/: util.h delay.c delay.h
  group Component/task
    ../Component/task/: app_tasks.c app_tasks.h
  group Component/Maixcam
    ../Component/maixcam/: maixcam.c maixcam.h
  group Component/gray_sensor
    ../Component/gray_sensor/: gray_sensor.c gray_sensor.h gray_sensor_config.h
  group Component/config
    ../Component/config/: task_params.c task_params.h
